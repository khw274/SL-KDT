/* **************************************************************************
 *			            C EXAM - CONDITION  
 * **************************************************************************/

 // =========================================================================
 // 단답형
 // =========================================================================
 // -------------------------------------------------------------------------
 // 1. if문의 조건식이 참으로 판단되는 기준은 무엇인가요?
 // -------------------------------------------------------------------------

 // ------------------------------------------------------------------------- 
 // 2. if ~ else if ~ else 구조는 어떤 상황에 적합한가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 3. switch문에서 분기 시작 키워드는 무엇인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 4. switch문에서 default의 역할은 무엇인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 5. switch문에서 break를 쓰는 이유는 무엇인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 6. switch문에서 사용할 수 없는 대표적인 자료형 1가지는?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 7. 중첩 if문이란 무엇인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 8. 조건 연산자(?:)는 어떤 문장을 축약한 형태인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 9. 논리 NOT 연산자는 무엇인가요?
 // -------------------------------------------------------------------------

 // -------------------------------------------------------------------------
 // 10. 범위 체크에 주로 사용하는 연산자는 무엇인가요?
 // -------------------------------------------------------------------------


 // =========================================================================
 // 코드형
 // =========================================================================
#include <stdio.h>
 // ------------------------------------------------------------------------- 
 // 1. 정수 1개를 입력받아 양수/0/음수를 if조건문으로 출력하세요.
 // -------------------------------------------------------------------------
void exam1() 
{

	int a = 0;
	printf("정수 1개를 입력하세요 : ");
	scanf("%d", &a);

	if (a > 0) 
	{
		printf("양수\n");
	}
	
	else if (a < 0) 
	{
		printf("음수\n");
	}
	
	else
	{
		printf("0");
	}
}

 // -------------------------------------------------------------------------
 // 2. 점수(0~100)를 입력받아 A/B/C/D/F를 출력하세요.
 // -------------------------------------------------------------------------

void exam2()
{
	int a = 0;
	printf("정수(0~100)를 입력하세요 : ");
	scanf("%d", &a);
}

 // -------------------------------------------------------------------------
 // 3. 연도를 입력받아 윤년 여부를 판별해 출력하세요.
 //    윤년 판단 기준 : 4의 배수이면서 100의 배수가 아니거나, 400의 배수
 // -------------------------------------------------------------------------

void exam3() 
{
	int year = 0;

	printf("연도를 입력해주세요 : ");
	scanf("%d", &year);

	if ((year % 4 == 0 && year % 100 != 0) || (year % 400 == 0)) {
		printf("윤년\n");
	}
	else {
		printf("윤년 아님\n");
	}
}

 // -------------------------------------------------------------------------
 // 4. 두 정수를 입력받아 큰 수를 출력하되 같으면 "same"을 출력하세요.
 // -------------------------------------------------------------------------

void exam4() {
	int a, b = 0;

	printf("두 정수를 입력하세요 : ");
	scanf("%d %d", &a, &b);

	if (a == b) {
		printf("same");

	}

	else if (a > b) {
		printf("%d", a);
	}

	else {
		printf("%d", b);
	}
	
}

 // -------------------------------------------------------------------------
 // 5. 정수 1개를 입력받아 절대값을 if로 구해 출력하세요.
 // -------------------------------------------------------------------------

void exam5() {
	
	int a = 0;
	printf("정수 1개를 입력하세요 : ");
	scanf("%d", &a);

	if (a < 0) {
		printf("%d의 절댓값은 : %d\n", a, -a);
	}
	else {
		printf("%d의 절댓값은 : %d\n", a, a);
	}
}

 // -------------------------------------------------------------------------
 // 6. 정수 1개를 입력받아 16진수, 8진수, 2진수 값 출력하세요.
 //    예: 21 => 0x15, 025, 0b00010101
 // -------------------------------------------------------------------------

void exam6() {

	int a;
	printf("정수 1개를 입력하세요 : ");
	scanf("%d", &a);

	printf("a의 16진수 : 0x%x\n", a);
	printf("%d의 8진수  : 0%o\n", a);

	printf("%d의 2진수  : 0b", a);

	for (int i = 7; i >= 0; i--) {
		printf("%d", (a >> i) & 1);
	}
}

 // -------------------------------------------------------------------------
 // 7. 사용자에게 "계속할까요? (y/n): " 를 출력 후 문자 1개를 입력 받으세요.
 //    입력 문자가 'y' 또는 'n' 이 아닐 경우, 다시 재입력을 받습니다. 
 //    'y'면 "계속 진행!"을 출력, 'n'이면 "종료!"를 출력하세요.
 // -------------------------------------------------------------------------

void exam7() {

		char a = 0;
		do {
			printf("y/n:");
			scanf(" %c", &a);

			if (a == 'Y' || a == 'y') {
				printf("계속진행\n");
			}
			else if (a == 'N' || a == 'n') {
				printf("그만\n");
			}
			else {
				printf("잘못 입력했습니다\n");
			}
		} while (a != 'N' && a != 'n');
		return 0;
}

 // -------------------------------------------------------------------------
 // 8. switch로 연산자(+,-,*,/)와 두 정수를 입력받아 계산 결과를 출력하세요. 
 //    (0 나누기 예외 처리)
 // -------------------------------------------------------------------------
void exam8() {
	char op;
	int a, b = 0;

	printf("두 정수와 연산자를 입력하세요 : ");
	scanf("%d %d %c", &a, &b, &op);

	switch (op) {
	case '+':
		printf("%d %c %d : %d\n", a, op, b, a + b);
		break;
	case '-':
		printf("%d %c %d : %d\n", a, op, b, a - b);
		break;
	case '*':
		printf("%d %c %d : %d\n", a, op, b, a * b);
		break;
	case '/':
		printf("%d %c %d : %d\n", a, op, b, a / b);
		break;
	default:
		printf("잘못된 연산자입니다!");
	}
}

 // -------------------------------------------------------------------------
 // 9. 세 정수를 입력받아 최댓값을 중첩 if로 출력하세요.
 // -------------------------------------------------------------------------

void exam9() {

	int a, b, c;
	int max = 0;

	printf("세 정수를 입력하세요 : ");
	scanf("%d %d %d", &a, &b, &c);

	if (a > b) {
		if (a > c) {
			max = a;
		}
		else {
			max = c;
		}
	}
	else {
		if (b > c) {
			max = b;
		}
		else {
			max = c;
		}
	}

	printf("최댓값은 : %d", max);
}

 // -------------------------------------------------------------------------
 // 10. 키(cm), 몸무게(kg) 입력받아 BMI를 계산하고 구간별 (저체중/정상/과체중
 //     /비만) 출력하세요  
 // bmi : 몸무게 / (키 * 키). cm_m
 // 18 이하가 저체중
 // 18.5~22.9가 정상
 // 23-24.9가 과체중
 // 25이상 비만
 // -------------------------------------------------------------------------
void exam10() {

	int height, weight = 0;

	printf("키, 몸무게를 입력하세요 : ");
	scanf("%d %d", &height, &weight);

	double M = height / 100.0;
	
	double BMI = weight / (double)(M * M);

	if (BMI < 18) {
		printf("저체중\n");
	}

	else if (BMI >= 18 && BMI <= 22.9) {
		printf("정상\n");
	}

	else if (BMI >= 23 && BMI <= 24.9) {
		printf("과제중\n");
	}

	else if (BMI >= 25) {
		printf("비만\n");
	}
}


int main(void) {
	exam10();
}