/* **************************************************************************
 *			                C EXAM - ARRAY 
 * **************************************************************************/

#include <stdio.h>
#include <stdlib.h>
#include <time.h>


// =========================================================================
// 단답형
// =========================================================================
 // -------------------------------------------------------------------------
 // 1. 배열의 필수 조건과 특징을 쓰세요.
 // -------------------------------------------------------------------------
 // 정답 : 같은 자료형의 여러 데이터를 연속(연속된 메모리 공간)에 저장하는 구조
 //        인덱스(index)로 각 원소에 접근한다.
 //        배열 크기(원소 개수)가 정해져 있다(선언 시 지정).


 // -------------------------------------------------------------------------
 // 2. 배열 선언 형식은 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답 : 자료형 배열명[원소개수];
 //        예) int arr[5];


 // -------------------------------------------------------------------------
 // 3. 배열 인덱스는 몇부터 시작하나요?
 // -------------------------------------------------------------------------
 // 정답 : 0부터 시작한다.


 // -------------------------------------------------------------------------
 // 4. 배열의 유효한 인덱스 범위는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답 : 0 ~ (배열크기 - 1)
 //        예) int a[5]라면 0~4


 // -------------------------------------------------------------------------
 // 5. float nums[] = {4.3, 2.1, 0.9}에서 배열 원소 개수를 구하는 방법은?
 // -------------------------------------------------------------------------
 // 정답 : sizeof(nums) / sizeof(nums[0])


 // -------------------------------------------------------------------------
 // 6. int a[5] = {1,2}; 와 같이 일부만 초기화하면 나머지 값은 어떻게 되나요?
 // -------------------------------------------------------------------------
 // 정답 : 나머지 원소는 0으로 자동 초기화된다.
 //        (a[0]=1, a[1]=2, a[2]=0, a[3]=0, a[4]=0)


 // -------------------------------------------------------------------------
 // 7. 배열 초기화에서 int a[3] = {1,2,3}; 의 의미는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답 : a[0]=1, a[1]=2, a[2]=3 으로 각 원소가 순서대로 초기화된다는 뜻


 // -------------------------------------------------------------------------
 // 8. short형 배열 원소 50개를 모두 0으로 초기화하는 방법은?
 // -------------------------------------------------------------------------
 // 정답 : short a[50] = {0};
 //        또는 반복문으로 a[i]=0을 50번 수행


 // -------------------------------------------------------------------------
 // 9. 문자열 저장용 char 배열에서 끝에 반드시 필요한 문자는?
 // -------------------------------------------------------------------------
 // 정답 : 널 문자 '\0'


 // -------------------------------------------------------------------------
 // 10. 배열 범위를 벗어난 접근은 어떤 문제가 되나요?
 // -------------------------------------------------------------------------
 // 정답 : 미정의 동작(Undefined Behavior)
 //        값이 깨지거나, 다른 메모리 손상, 프로그램 오류/비정상 종료 등이 
 //        발생할 수 있다.



 // -------------------------------------------------------------
 // [9번] 배열을 함수로 전달하여 합을 반환하는 함수
 // -------------------------------------------------------------
int sum_array(const int arr[], int size)
{
    int sum = 0;
    for (int i = 0; i < size; i++)
        sum += arr[i];
    return sum;
}

// =========================================================================
// 코드형
// =========================================================================
int main(void)
{
    srand((unsigned)time(NULL));

    // -------------------------------------------------------------------------
    // 1. int arr[5]를 선언하고 1~5로 초기화한 뒤 모두 출력하세요.
    // -------------------------------------------------------------------------
    printf("\n[1] arr[5] = {1,2,3,4,5} 출력\n");
    {
        int arr[5] = { 1,2,3,4,5 };
        for (int i = 0; i < 5; i++)
            printf("%d ", arr[i]);
        printf("\n");
    }

    // -------------------------------------------------------------------------
    // 2. 사용자로부터 5개 정수를 입력받아 배열에 저장 후 합과 평균 출력
    // -------------------------------------------------------------------------
    printf("\n[2] 정수 5개 입력 -> 합/평균\n");
    {
        int arr[5];
        int sum = 0;

        printf("정수 5개 입력\n");
        for (int i = 0; i < 5; i++)
        {
            printf("%d번째 입력:", i);
            if (scanf("%d", &arr[i]) != 1) return 0;
        }

        for (int i = 0; i < 5; i++)
            sum += arr[i];

        double avg = (double)sum / 5.0;
        printf("합 = %d\n", sum);
        printf("평균 = %.2f\n", avg);
    }

    // -------------------------------------------------------------------------
    // 3. 배열 5개 요소에서 최댓값과 최솟값을 찾아 출력하세요.
    // -------------------------------------------------------------------------
    printf("\n[3] 배열 최댓값/최솟값\n");
    {
        int arr[5];

        printf("정수 5개 입력\n");
        for (int i = 0; i < 5; i++)
        {
            printf("%d번째 입력:", i);
            if (scanf("%d", &arr[i]) != 1) return 0;
        }

        int max = arr[0], min = arr[0];
        for (int i = 1; i < 5; i++)
        {
            if (arr[i] > max) max = arr[i];
            if (arr[i] < min) min = arr[i];
        }

        printf("최댓값 = %d\n", max);
        printf("최솟값 = %d\n", min);
    }

    // -------------------------------------------------------------------------
    // 4. 1~50 랜덤 20개 배열 생성 후 짝수만 출력
    // -------------------------------------------------------------------------
    printf("\n[4] 1~50 랜덤 20개 -> 짝수만 출력\n");
    {
        int arr[20];

        for (int i = 0; i < 20; i++)
            arr[i] = (rand() % 50) + 1;

        printf("전체: ");
        for (int i = 0; i < 20; i++) printf("%d ", arr[i]);
        printf("\n");

        printf("짝수: ");
        for (int i = 0; i < 20; i++)
            if (arr[i] % 2 == 0) printf("%d ", arr[i]);
        printf("\n");
    }

    // -------------------------------------------------------------------------
    // 5. "Good Luck" 대/소문자 반전 출력
    // -------------------------------------------------------------------------
    printf("\n[5] \"Good Luck\" 대/소문자 반전 출력\n");
    {
        char s[] = "Good Luck";

        for (int i = 0; s[i] != '\0'; i++)
        {
            char ch = s[i];

            if ('a' <= ch && ch <= 'z')      ch = ch - ('a' - 'A'); // 소->대
            else if ('A' <= ch && ch <= 'Z') ch = ch + ('a' - 'A'); // 대->소

            putchar(ch);
        }
        putchar('\n');
    }

    // -------------------------------------------------------------------------
    // 6. "Happy New Year" 문자열 길이 출력
    // -------------------------------------------------------------------------
    printf("\n[6] \"Happy New Year\" 길이 출력\n");
    {
        char s[] = "Happy New Year";
        int len = 0;

        while (s[len] != '\0')
            len++;

        printf("문자열 = %s\n", s);
        printf("길이(len) = %d\n", len);
    }

    // -------------------------------------------------------------------------
    // 7. int arr[10] 임의 값으로 채우고 특정 값 찾아 인덱스 출력(없으면 -1)
    // -------------------------------------------------------------------------
    printf("\n[7] arr[10]에서 특정 값 찾기(없으면 -1)\n");
    {
        // 지역변수 선언
        int arr[10];
        int target;
        int idx = -1;

        // 배열 값 채우기
        for (int i = 0; i < 10; i++)
            arr[i] = (rand() % 20) + 1;   // 1~20

        printf("배열: ");
        for (int i = 0; i < 10; i++)  printf("%d ", arr[i]);
        printf("\n");

        
        // 배열에서 값 찾기
        printf("찾을 값 입력: ");
        if(scanf("%d", &target) != 1) return 0;

        // 검색 결과 처리 
        for (int i = 0; i < 10; i++)
        {
            if (arr[i] == target)
            {
                idx = i;
                break;
            }
        }

        printf("인덱스 = %d\n", idx);
    }

    // -------------------------------------------------------------------------
    // 8. "Happy New Year"에서 대문자/소문자 개수 출력
    // -------------------------------------------------------------------------
    printf("\n[8] \"Happy New Year\" 대문자/소문자 개수\n");
    {
        char s[] = "Happy New Year";
        int upper = 0, lower = 0;

        for (int i = 0; s[i] != '\0'; i++)
        {
            if ('A' <= s[i] && s[i] <= 'Z') upper++;
            else if ('a' <= s[i] && s[i] <= 'z') lower++;
        }

        printf("문자열 = %s\n", s);
        printf("대문자 개수 = %d\n", upper);
        printf("소문자 개수 = %d\n", lower);
    }

    // -------------------------------------------------------------------------
    // 9. 배열을 함수로 전달하여 모든 원소 합을 반환하는 함수를 작성하세요.
    // -------------------------------------------------------------------------
    printf("\n[9] 함수로 배열 전달 -> 합 반환\n");
    {
        int arr[5];
        printf("정수 5개 입력 (예 9 7 4 5 6):");
        if (scanf("%d%d%d%d%d", &arr[0], &arr[1], &arr[2], &arr[3], &arr[4]) != 5) return 0;

        int sum = sum_array(arr, 5);
        printf("합 = %d\n", sum);
    }

    // -------------------------------------------------------------------------
    // 10. "Good Luck" 문자열을 ASCII 코드값으로 출력
    // -------------------------------------------------------------------------
    printf("\n[10] \"Good Luck\" ASCII 코드 출력\n");
    {
        char s[] = "Good Luck";

        printf("문자열: %s\n", s);
        printf("ASCII : ");
        for (int i = 0; s[i] != '\0'; i++)
            printf("%d ", (int)s[i]);
        printf("\n");
    }

    return 0;
}
