/* **************************************************************************
 *								C EXAM - BASIC
 * **************************************************************************/
 // 김현우
 // *************************************************************************
 // 단답형
 // *************************************************************************
 // -------------------------------------------------------------------------
 // 1. C언어에서 정수형 자료형 4가지를 쓰세요.
 // -------------------------------------------------------------------------
 // 답: short, int, long, long long
 // 
 // -------------------------------------------------------------------------
 // 2. char형은 내부적으로 어떤 “정수 단위”로 처리되나요?
 // -------------------------------------------------------------------------
 // 답: ASCII코드 정수 단위
 // 
 // -------------------------------------------------------------------------
 // 3. signed int와 unsigned int의 표현 범위 차이를 한 문장으로 쓰세요.
 // -------------------------------------------------------------------------
 // 답: signed int: 음수 ~ 양수 표현, unsigned int: 0 ~ 양수 표현 
 // 
 // -------------------------------------------------------------------------
 // 4. 관계 연산자의 결과가 if문에서 참/거짓으로 판단되는 기준을 쓰세요.
 // -------------------------------------------------------------------------
 // 답: 0이면 거짓, 1이면 참
 // 
 // -------------------------------------------------------------------------
 // 5. 다음 중 단락 평가(short-circuit)가 발생하는 연산자를 모두 쓰세요.
 // -------------------------------------------------------------------------
 // 답: && , ||
 // 
 // -------------------------------------------------------------------------
 // 6. i++ 와 ++i 를 수식 안에서 사용할 때 주의할 점을 쓰세요.
 // -------------------------------------------------------------------------
 // 답: i++은 사용 후 증가하고, ++i는 증가하고 사용된다.

 // -------------------------------------------------------------------------
 // 7. switch문에서 break를 생략했을 때 발생하는 동작을 용어로 쓰세요.
 // -------------------------------------------------------------------------
 // 답: fall-through

 // -------------------------------------------------------------------------
 // 8. 다음 배열 선언에서 메모리에 할당되는 전체 바이트 수를 계산해주세요.
 //     int arr[10];
 // -------------------------------------------------------------------------
 // 답: 40 바이트

 // -------------------------------------------------------------------------
 // 9. int형이 4바이트일 때, 최상위 비트(MSB)의 의미를 쓰세요.
 // -------------------------------------------------------------------------
 // 최상위 비트는 부호 비트이다. (0이면 양수, 1이면 음수)

 // -------------------------------------------------------------------------
 // 10. 2의 보수 설명하세요.
 // -------------------------------------------------------------------------
 // 비트를 반전시키고(0 -> 1, 1 -> 0, 1의 보수), 1을 더한 값.
 // 
 // -------------------------------------------------------------------------
 // 11. 2진수에서 특정 비트값을 0으로 세팅하기 위해서 필요한 연산은?
 // -------------------------------------------------------------------------
 // AND 연산

 // -------------------------------------------------------------------------
 // 12. 배열 인덱스를 잘못 사용했을 때 발생 가능한 문제를 쓰세요.
 // -------------------------------------------------------------------------
 // 배열 인덱스를 초과하거나 잘못 지정하면 쓰레기값을 참조하게 될 수 있다.

 // -------------------------------------------------------------------------
 // 13. for문과 while문의 사용 목적 차이를 쓰세요.
 // -------------------------------------------------------------------------
 // for문은 반복 횟수를 명확하게 지정했을 때 사용하고, while문은 반복을 하는 이유/조건이 명확할 때 사용한다.

 // -------------------------------------------------------------------------
 // 14. 초기화되지 않은 지역 변수를 사용하는 것이 위험한 이유를 쓰세요.
 // -------------------------------------------------------------------------
 // 지역 변수를 초기화하지 않으면 쓰레기값으로 초기화되어 있기 때문이다.

 // -------------------------------------------------------------------------
 // 15. &, * 연산자 설명하세요.
 // -------------------------------------------------------------------------
 // & 연산자는 변수의 주소를 의미하는 주소 연산자이고, * 는 포인터 연산자이다.

 // *************************************************************************
 // 코드형   
 // *************************************************************************
#include <stdio.h>
// -------------------------------------------------------------------------
// 1. 세 정수 a, b, c를 입력받아 큰 값과 작은 값을 출력하세요.
//    단, if문 사용 금지 (삼항 연산자만 사용)
// -------------------------------------------------------------------------
void exam1()
{

	int a, b, c;
	printf("세 정수를 입력하세요 : ");
	scanf("%d %d %d", &a, &b, &c);

	int max = (a > b) ? ((a > c) ? a : c) : ((b > c) ? b : c);
	int min = (a < b) ? ((a < c) ? a : c) : ((b < c) ? b : c);

	printf("세 정수 중 큰 값 : %d, 작은 값 : %d", max, min);
}
// -------------------------------------------------------------------------
// 2. 입력 받은 문자열에 대한 16진수 값을 출력하세요.
// -------------------------------------------------------------------------
void exam2()
{

	char str[5];
	printf("문자 5개를 입력하세요 : ");
	scanf("%s", &str);

	for (int i = 0; str[i] != '\0'; i++)
	{
		printf("받은 문자열의 16진수 값 : 0x%X\n", str[i]);
	}
}

// -------------------------------------------------------------------------
// 3. 정수 n을 입력받아 n의 약수를 모두 출력하세요.
// -------------------------------------------------------------------------
void exam3()
{

	int a = 0;
	printf("정수 1개를 입력하세요 : ");
	scanf("%d", &a);

	printf("정수 %d의 약수 : ", a);
	for (int i = 1; i <= a; i++)
	{
		if (a % i == 0) printf("%d ", i);

	}
}

// -------------------------------------------------------------------------
// 4. 정수 n을 입력받아 n!을 계산하세요.
//    단, 결과가 int 범위를 넘지 않는다고 가정
// -------------------------------------------------------------------------
void exam4()
{

	int n = 0;
	int result = 1;

	printf("정수 n을 입력하세요 : ");
	scanf("%d", &n);

	for (int i = n; i > 0; i--)
	{
		result *= i;
	}

	printf("%d! = %d", n, result);
}
// -------------------------------------------------------------------------
// 5. 사용자로부터 양수를 입력 받고 해당 숫자의 합계와 숫자 개수를 
//    출력하세요.
// -------------------------------------------------------------------------
void exam5()
{
	unsigned int a = 0;
	int count = 0;
	int sum = 0;

	printf("양수 1개를 입력하세요 : ");
	scanf("%u", &a);

	while (a > 0) {
		sum += a % 10;  // 10으로 나눈 나머지(마지막 자리수)를 더함
		count++;        // 자리수 카운트 증가
		a /= 10;        // 10으로 나누어 마지막 자리수 제거
	}

	printf("각 자리수의 합계: %d\n", sum);
	printf("       숫자 개수: %d", count);

}

// -------------------------------------------------------------------------
// 6. 길이 n 배열을 입력받아
//     같은 값이 연속으로 몇 번 나오는지 출력하세요.
//     예) 1 1 1 2 2 3 → 3 2 1
// -------------------------------------------------------------------------
void exam6()
{
	int arr[6] = { 0 };

	printf("길이 6만큼의 배열을 입력하세요(예 : 1 1 1 2 2 3) : ");

	for (int i = 0; i < 6; i++)
	{
		scanf("%d", &arr[i]);
	}

	int count = 1;

	for (int i = 0; i < 5; i++)
	{
		if (arr[i] == arr[i + 1]) count++;
		else {
			printf("%d ", count);
			count = 1;
		}
	}

	printf("%d", count);
}

// -------------------------------------------------------------------------
// 7. 10개 원소 배열에서 특정 값 x가 처음 등장하는 인덱스를 출력하세요.
//     없으면 -1 출력.
//     단, 1~100범위의 임의의 난수로 배열 구성하세요.
// -------------------------------------------------------------------------
void exam7()
{
	int arr[10];
	int x = 0;
	int idx = 0;

	printf("10개의 원소를 입력하세요 : ");
	for (int i = 0; i < 10; i++)
	{
		scanf("d", &arr[i]);
	}

	printf("특정 값 x를 입력하세요 : ");
	scanf("%d", &x);

	for (int i = 0; i < 10; i++)
	{
		if (arr[i] == x)
		{
			idx = i;
			printf("인덱스 : %d", idx);
			break;
		}
	}

}

// -------------------------------------------------------------------------
// 8. 정수 x와 k를 입력받아
//     k번째 비트가 1이면 0으로, 0이면 1로 토글하세요.
// -------------------------------------------------------------------------
void exam8()
{
	int x, k;
	printf("정수 x와 k를 입력하세요 : ");
	scanf("%d %d", &x, &k);

	int result = 0;
	result = ((x >> k) & 1);
	//printf("%d", result);

	if (result == 1)
	{
		x = x ^ (1 << k);
	}
	else if (result == 0) {
		x = (x | (1 << k));
	}

	printf("%d", x);
}

// -------------------------------------------------------------------------
// 9. 정수 배열에서 값이 증가했다가 감소하는 봉우리 개수를 구하세요.
//     예) 1 3 5 4 2 6 3 → 2
// -------------------------------------------------------------------------
//void exam9()
//{
//	
//}

// -------------------------------------------------------------------------
// 10. 1~100 범위에 소수(prime)를 출력하세요.
//     소수는 1과 자기 자신으로만 나누어 떨어지는 1보다 큰 자연수이며, 
//     예시로 2, 3, 5, 7, 11, 13, 17, 19, 23, 29, 31, 37... 
// -------------------------------------------------------------------------
void exam10()
{
	for (int i = 2; i <= 100; i++)
	{
		int sosu = 1;

		for (int j = 2; j * j <= i; j++) // 수의 제곱근까지
		{
			if (i % j == 0)
			{
				sosu = 0;
				break;
			}
		}

		if (sosu == 1) printf("%d ", i);

	}
}

int main(void) {

	exam7();
}

