/* **************************************************************************
 *			            C EXAM - OPERATOR (ANSWER)
 * **************************************************************************/

#include <stdio.h>

 // =========================================================================
 // 단답형 (정답)
 // =========================================================================
 // -------------------------------------------------------------------------
 // 1. 산술 연산자 5가지를 쓰세요.
 // -------------------------------------------------------------------------
 // 정답: +, -, *, /, %

 // ------------------------------------------------------------------------- 
 // 2. 나머지를 구하는 연산자는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: %

 // -------------------------------------------------------------------------
 // 3. 관계 연산자의 결과값은 어떤 값(형태)으로 판단되나요?
 // -------------------------------------------------------------------------
 // 정답: 참(0이 아님) / 거짓(0)  (보통 1 또는 0)

 // -------------------------------------------------------------------------
 // 4. 논리 AND 연산자와 비트 AND 연산자를 각각 쓰세요.
 // -------------------------------------------------------------------------
 // 정답: 논리 AND = && , 비트 AND = &   

 // ------------------------------------------------------------------------- 
 // 5. i++ 와 ++i 의 차이를 한 문장으로 쓰세요.
 // -------------------------------------------------------------------------
 // 정답: i++는 값을 사용한 후 증가, ++i는 증가한 후 값을 사용한다.

 // -------------------------------------------------------------------------
 // 6. 삼항 연산자의 기본 형태를 쓰세요.
 // -------------------------------------------------------------------------
 // 정답: (조건식) ? (참일 때 식/값) : (거짓일 때 식/값)

 // -------------------------------------------------------------------------
 // 7. 단락 평가(short-circuit evaluation)가 발생하는 논리 연산자는?
 //    단락 평가 : 논리 연산에서 결과 확정되면 나머지 피연산자 평가하지 않는 것
 // -------------------------------------------------------------------------
 // 정답: &&, ||
 //       A && B  : A가 거짓(0) → B는 평가하지 않음
 //       A || B  : A가 참(0이 아님) → B는 평가하지 않음

 // -------------------------------------------------------------------------
 // 8. sizeof는 함수인가요 연산자인가요?
 // -------------------------------------------------------------------------
 // 정답: 연산자

 // ------------------------------------------------------------------------- 
 // 9. 포인터 역참조 연산자는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: *

 // -------------------------------------------------------------------------
 // 10. 비트 왼쪽 시프트 연산자는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: <<


 // =========================================================================
 // 코드형 
 // =========================================================================

int main(void)
{
     // -------------------------------------------------------------------------
     // 1. 정수 2개를 입력받아 +, -, *, /, % 결과를 출력하세요. 
     //    (0 나누기 예외 처리 포함)
     // -------------------------------------------------------------------------
     printf("\n[1] 정수 2개를 입력받아 +, -, *, /, % 결과를 출력\n");
     {
         int a, b;
         printf("정수 2개 입력: ");
         if (scanf("%d %d", &a, &b) != 2) return 0;

         printf("a + b = %d\n", a + b);
         printf("a - b = %d\n", a - b);
         printf("a * b = %d\n", a * b);

         if (b != 0)
         {
             printf("a / b = %d\n", a / b);
             printf("a %% b = %d\n", a % b);
         }
         else
         {
             printf("a / b = (불가: 0으로 나눌 수 없음)\n");
             printf("a %% b = (불가: 0으로 나눌 수 없음)\n");
         }

     }

     
     // -------------------------------------------------------------------------
     // 2. 정수 1개를 입력받아 삼항 연산자로 홀/짝을 출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[2] 정수 1개를 입력받아 삼항 연산자로 홀/짝을 출력\n");
     {
         int n;
         printf("정수 1개 입력: ");
         if (scanf("%d", &n) != 1) return 0;

         (n % 2 == 0) ? printf("짝수\n") : printf("홀수\n");
     }

     
     // -------------------------------------------------------------------------
     // 3. i=5로 시작하여 i++와 ++i를 각각 출력해 차이를 보여주는 코드를 작성하세요.
     // -------------------------------------------------------------------------
     printf("\n[3] i=5로 시작하여 i++와 ++i를 각각 출력해 차이를 보여주는 코드를 작성\n");
     {
         int i = 5;

         printf("초기 i = %d\n", i);
         printf("i++ 출력값 = %d\n", i++);
         printf("i++ 후 i   = %d\n\n", i);

         i = 5;
         printf("초기 i = %d\n", i);
         printf("++i 출력값 = %d\n", ++i);
         printf("++i 후 i   = %d\n", i);

     }

    
     // -------------------------------------------------------------------------
     // 4. 두 정수 a, b 중 큰 값을 삼항 연산자로 구해 출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[4]  두 정수 a, b 중 큰 값을 삼항 연산자로 구해 출력\n");
     {
         int a, b;
         printf("정수 2개 입력: ");
         if (scanf("%d %d", &a, &b) != 2) return 0;

         int max = (a > b) ? a : b;
         printf("큰 값 = %d\n", max);
     }


     
     // -------------------------------------------------------------------------
     // 5. 정수 1개를 입력받아 LSB(최하위 비트)가 1인지 0인지 (&1)로 출력하세요.
     //    0000 0000
     //   ↑       ↑
     //  MSB       LSB
     // -------------------------------------------------------------------------
     printf("\n[5] 정수 1개를 입력받아 LSB(최하위 비트)가 1인지 0인지 (&1)로 출력\n");
     {
         int n;
         printf("정수 1개 입력: ");
         if (scanf("%d", &n) != 1) return 0;

         printf("LSB = %d\n", (n & 1));
     }
     
     // -------------------------------------------------------------------------
     // 6. 정수 m과 비트 위치 n을 입력받아, m의 n번째 비트가 1인지 0인지 출력하세요. 
     // -------------------------------------------------------------------------
     printf("\n[6] 정수 m과 비트 위치 n을 입력받아, m의 n번째 비트가 1인지 0인지 출력\n");
     {
         int m, n;

         printf("정수 m 입력: ");
         if (scanf("%d", &m) != 1) return 0;

         printf("비트 위치 n 입력 (0부터 시작): ");
         if (scanf("%d", &n) != 1) return 0;

         m = m | (1 << n);       // n번째 비트 SET

         printf("결과 값 = %d\n", m);

     }


     
     // ------------------------------------------------------------------------- 
     // 7. 정수 1개를 입력받아 1비트 left shift / right shift 결과를 출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[7] 정수 1개를 입력받아 1비트 left shift / right shift 결과를 출력\n");
     {
         int k;
         printf("정수 1개 입력: ");
         if (scanf("%d", &k) != 1) return 0;

         printf("k      = %d\n", k);
         printf("k << 1 = %d\n", (k << 1));
         printf("k >> 1 = %d\n", (k >> 1));
     }


     
     // -------------------------------------------------------------------------
     // 8. 정수 1개를 입력받아 비트 반전(~) 결과를 출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[8] 정수 1개를 입력받아 비트 반전(~) 결과를 출력\n");
     {
         int k;
         printf("정수 1개 입력: ");
         if (scanf("%d", &k) != 1) return 0;

         printf("k  = %d\n", k);
         printf("~k = %d\n", ~k);

     }


    
     // -------------------------------------------------------------------------
     // 9. 정수 m과 비트 위치 n을 입력받아, m의 n번째 비트를 1로 설정한 결과를 
     //    출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[9] 정수 m과 비트 위치 n을 입력받아, m의 n번째 비트를 1로 설정한 결과\n");
     {
         int m, n;

         printf("정수 m 입력: ");
         if (scanf("%d", &m) != 1) return 0;

         printf("비트 위치 n 입력 (0부터 시작): ");
         if (scanf("%d", &n) != 1) return 0;

         if ((m >> n) & 1)
             printf("%d번째 비트는 1입니다.\n", n);
         else
             printf("%d번째 비트는 0입니다.\n", n);
     }


     
     // -------------------------------------------------------------------------
     // 10. 복합대입연산자 (a2 += b2*2)를 사용해 계산 결과를 출력하세요.
     // -------------------------------------------------------------------------
     printf("\n[10] 복합대입연산자 (a2 += b2*2)를 사용해 계산 결과를 출력\n"); 
     {
         int a, b;
         printf("정수 2개 입력(a b): ");
         if (scanf("%d %d", &a, &b) != 2) return 0;

         a += b * 2;
         printf("a 결과 = %d\n", a);
     }


return 0;
}
