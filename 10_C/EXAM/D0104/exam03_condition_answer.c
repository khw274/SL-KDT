/* **************************************************************************
 *			            C EXAM - CONDITION
 * **************************************************************************/
#include <stdio.h>

 // =========================================================================
 // 단답형
 // =========================================================================
 // -------------------------------------------------------------------------
 // 1. if문의 조건식이 참으로 판단되는 기준은 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: if 조건식 참 기준: 0이 아니면 참, 0이면 거짓
 

 // ------------------------------------------------------------------------- 
 // 2. if ~ else if ~ else 구조는 어떤 상황에 적합한가요?
 // -------------------------------------------------------------------------
 // 정답: 여러 조건 중 하나 선택(다중 분기/구간 판정)


 // -------------------------------------------------------------------------
 // 3. switch문에서 분기 시작 키워드는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: case


 // -------------------------------------------------------------------------
 // 4. switch문에서 default의 역할은 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: 어떤 case에도 해당하지 않을 때 실행



 // -------------------------------------------------------------------------
 // 5. switch문에서 break를 쓰는 이유는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: switch 탈출(다음 case로 내려가는 fall-through 방지)


 // -------------------------------------------------------------------------
 // 6. switch문에서 사용할 수 없는 대표적인 자료형 1가지는?
 // -------------------------------------------------------------------------
 // 정답: float/double 같은 실수형
//       가능한 자료형 => int, char, 상수


 // -------------------------------------------------------------------------
 // 7. 중첩 if문이란 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답:  if문 안에 if문이 또 있는 구조


 // -------------------------------------------------------------------------
 // 8. 조건 연산자(?:)는 어떤 문장을 축약한 형태인가요?
 // -------------------------------------------------------------------------
 // 정답:  if-else


 // -------------------------------------------------------------------------
 // 9. 논리 NOT 연산자는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답:  !


 // -------------------------------------------------------------------------
 // 10. 범위 체크에 주로 사용하는 연산자는 무엇인가요?
 // -------------------------------------------------------------------------
 // 정답: 관계연산자(<=,>= 등) + 논리 AND(&&)


 // =========================================================================
 // 코드형
 // =========================================================================

int main(void)
{
	// ------------------------------------------------------------------------- 
	// 1. 정수 1개를 입력받아 양수/0/음수를 if조건문으로 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[1] 양수/0/음수 판별\n");
	{
		int n;
		printf("정수 입력: ");
		if(scanf("%d", &n) != 1) return 0;

		if (n > 0)       printf("양수\n");
		else if (n == 0) printf("0\n");
		else             printf("음수\n");
	}


	// -------------------------------------------------------------------------
	// 2. 점수(0~100)를 입력받아 A/B/C/D/F를 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[2] 점수 등급(A/B/C/D/F)\n");
	{
		int score;
		printf("점수 입력(0~100): ");
		if(scanf("%d", &score) != 1) return 0;

		if (score < 0 || score > 100)
		{
			printf("입력 오류(0~100)\n");
		}
		else if (score >= 90) printf("A\n");
		else if (score >= 80) printf("B\n");
		else if (score >= 70) printf("C\n");
		else if (score >= 60) printf("D\n");
		else                  printf("F\n");
	}


	// -------------------------------------------------------------------------
	// 3. 연도를 입력받아 윤년 여부를 판별해 출력하세요.
	//    윤년 판단 기준 : 4의 배수이면서 100의 배수가 아니거나, 400의 배수
	// -------------------------------------------------------------------------
	printf("\n[3] 윤년 판별\n");
	{
		int year;
		printf("연도 입력: ");
		if(scanf("%d", &year) != 1) return 0;

		if ((year % 4 == 0 && year % 100 != 0) || (year % 400 == 0))
			printf("윤년\n");
		else
			printf("평년\n");
	}


	// -------------------------------------------------------------------------
	// 4. 두 정수를 입력받아 큰 수를 출력하되 같으면 "same"을 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[4] 두 정수 비교(큰 수 / same)\n");
	{
		int a, b;
		printf("정수 2개 입력: ");
		if(scanf("%d %d", &a, &b) != 2) return 0;

		if (a > b)      printf("%d\n", a);
		else if (b > a) printf("%d\n", b);
		else            printf("same\n");
	}


	// -------------------------------------------------------------------------
	// 5. 정수 1개를 입력받아 절대값을 if로 구해 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[5] 절대값 출력\n");
	{
		int n;
		printf("정수 입력: ");
		if(scanf("%d", &n) != 1) return 0;

		if (n < 0) n = -n;
		printf("절대값 = %d\n", n);
	}


	// -------------------------------------------------------------------------
	// 6. 정수 1개를 입력받아 16진수, 8진수, 2진수 값 출력하세요.
	//    예: 21 => 0x15, 025, 0b00010101
	// -------------------------------------------------------------------------
	printf("\n[6] 16진/8진/2진 출력(8비트)\n");
	{
		int n;
		printf("정수 입력(0~255 권장): ");
		if(scanf("%d", &n)  != 1) return 0;

		printf("16진수: 0x%X\n", n);
		printf("8진수 : 0%o\n", n);

		printf("2진수 : 0b");
		for (int i = 7; i >= 0; i--)
			printf("%d", (n >> i) & 1);
		printf("\n");
	}


	// -------------------------------------------------------------------------
	// 7. 사용자에게 "계속할까요? (y/n): " 를 출력 후 문자 1개를 입력 받으세요.
	//    입력 문자가 'y' 또는 'n' 이 아닐 경우, 다시 재입력을 받습니다. 
	//    'y'면 "계속 진행!"을 출력, 'n'이면 "종료!"를 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[7] y/n 입력 검증(do~while)\n");
	{
		char ch;
		do
		{
			printf("계속할까요? (y/n): ");
			if (scanf(" %c", &ch) != 1) return 0;   // 앞 공백: 개행(엔터) 스킵
		} while (ch != 'y' && ch != 'n');

		if (ch == 'y') printf("계속 진행!\n");
		else           printf("종료!\n");
	}


	// -------------------------------------------------------------------------
	// 8. switch로 연산자(+,-,*,/)와 두 정수를 입력받아 계산 결과를 출력하세요. 
	//    (0 나누기 예외 처리)
	// -------------------------------------------------------------------------
	printf("\n[8] switch 계산기(+,-,*,/)\n");
	{
		char op;
		int a, b;

		printf("연산자 입력(+,-,*,/): ");
		if (scanf(" %c", &op) != 1) return 0;
		printf("정수 2개 입력: ");
		if (scanf("%d %d", &a, &b) != 2) return 0;

		switch (op)
		{
		case '+': printf("%d\n", a + b); break;
		case '-': printf("%d\n", a - b); break;
		case '*': printf("%d\n", a * b); break;
		case '/':
			if (b == 0) printf("0으로 나눌 수 없습니다.\n");
			else        printf("%f\n", (float)a / b);
			break;
		default:
			printf("잘못된 연산자입니다.\n");
			break;
		}
	}


	// -------------------------------------------------------------------------
	// 9. 세 정수를 입력받아 최댓값을 중첩 if로 출력하세요.
	// -------------------------------------------------------------------------
	printf("\n[9] 세 정수 최댓값(중첩 if)\n");
	{
		int a, b, c;
		printf("정수 3개 입력: ");
		if(scanf("%d %d %d", &a, &b, &c) !=3) return 0;

		int max;
		if (a >= b)
		{
			if (a >= c) max = a;
			else        max = c;
		}
		else
		{
			if (b >= c) max = b;
			else        max = c;
		}
		printf("최댓값 = %d\n", max);
	}


	// -------------------------------------------------------------------------
	// 10. 키(cm), 몸무게(kg) 입력받아 BMI 계산 후 구간별 출력
	//     (저체중/정상/과체중/비만)
	// -------------------------------------------------------------------------
	printf("\n[10] BMI 판정\n");
	{
		double cm, kg;
		printf("키(cm) 입력: ");
		if(scanf("%lf", &cm) != 1) return 0;
		printf("몸무게(kg) 입력: ");
		if(scanf("%lf", &kg) != 1) return 0;

		if (cm <= 0 || kg <= 0)
		{
			printf("입력 오류\n");
		}
		else
		{
			double m = cm / 100.0;
			double bmi = kg / (m * m);
			printf("BMI = %.2f\n", bmi);

			// 일반적으로 많이 쓰는 구간(학습용)
			if (bmi < 18.5)       printf("저체중\n");
			else if (bmi < 23.0)  printf("정상\n");
			else if (bmi < 25.0)  printf("과체중\n");
			else                  printf("비만\n");
		}
	}

	return 0;
}
