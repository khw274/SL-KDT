/* *******************************************************************
* File name    : sub_gugudan.c
* subFile name : X
* Description  : 구구단 프로그램 sub 파일(함수 구현)
* Author       : HyeonWoo
* History      : 2026.01.06 HyeonWoo
* ********************************************************************/
// -------------------------------------------------------------------
// 1. 전처리기 - 헤더파일 포함 
// -------------------------------------------------------------------
#include <stdio.h>
#include "gugudan.h"	// 본인 헤더파일 검증

// -------------------------------------------------------------------
// 2. 매크로 상수 정의 
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 3. 구조체 정의 (필요 시) 
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 4. 전역 변수/상수 선언 (Global Variable / constant)
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 5. 함수 선언 
// -------------------------------------------------------------------
int multiply(int x, int y);
int get_user_input(void);
void print_gugudan(int dan);
void print_gugudan_all(void);

// -------------------------------------------------------------------
// 6. 메인 함수 
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 7. 함수 구현 
// -------------------------------------------------------------------
int multiply(int x, int y)
{
	int result = x * y;

	return result;
}

int get_user_input(void)
{
	int num;

	printf("input a number(2~9) : ");
	scanf("%d", &num);

	return num;
}

void print_gugudan(int dan)
{
	for (int i = 1; i <= 9; i++)
	{
		int result = multiply(dan, i);
		printf("%d * %d = %2d\n", dan, i, result);
	}
}

void print_gugudan_all(void)
{
	for (int i = 1; i <= 9; i++)
	{
		for (int j = 1; j <= 9; j++)
		{
			printf("%d * %d = % 2d\n", i, j, multiply(i, j));
		}
		printf("\n");
	}
}
