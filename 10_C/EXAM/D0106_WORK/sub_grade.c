/* *******************************************************************
* File name    : sub_grade.c
* subFile name : X
* Description  : 성적 계산 프로그램 sub 파일(함수 구현)
* Author       : HyeonWoo
* History      : 2026.01.06 HyeonWoo
* ********************************************************************/
// -------------------------------------------------------------------
// 1. 전처리기 - 헤더파일 포함 
// -------------------------------------------------------------------
#include <stdio.h>
#include "grade.h"	// 본인 헤더파일 검증

// -------------------------------------------------------------------
// 2. 매크로 상수 정의 
// -------------------------------------------------------------------
#define STU 4
#define SUB 3

// -------------------------------------------------------------------
// 3. 구조체 정의 (필요 시) 
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 4. 전역 변수/상수 선언 (Global Variable / constant)
// -------------------------------------------------------------------
int score[STU + 1][SUB + 1] = {
	{ 100, 100, 100 },
	{ 25, 20, 20 },
	{ 35, 30, 30 },
	{ 45, 40, 40 }
};

// -------------------------------------------------------------------
// 5. 함수 선언 
// -------------------------------------------------------------------
void sum_score(void);
void print_score(void);

// -------------------------------------------------------------------
// 6. 메인 함수 
// -------------------------------------------------------------------

// -------------------------------------------------------------------
// 7. 함수 구현 
// -------------------------------------------------------------------
void sum_score(void)
{
	for (int i = 0; i < STU; i++)
	{
		for (int j = 0; j < SUB; j++)
		{
			score[i][SUB] += score[i][j];
			score[STU][j] += score[i][j];
		}
	}
}

void print_score(void)
{
	printf("번호 국어 영어 수학 총점 평균 \n");
	printf("=========================================\n");

	for (int i = 0; i < STU; i++)
	{
		printf("  %d    ", i + 1);

		for (int j = 0; j < SUB; j++)
		{
			printf("%3d  ", score[i][j]);
		}
		printf(" %3d   %5.1f\n", score[i][SUB], score[i][SUB] / (float)SUB);
	}
	printf("=========================================\n총점");

	for (int j = 0; j < SUB; j++)
	{
		printf("  %3d ", score[STU][j]);
	}
	puts("");
}